<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\WB55-p2p-Server-Legacy-OOB-UART.ewp</path>
  </project>
  <batchBuild />
</workspace>
